FILESEXTRAPATHS_append := "${THISDIR}/files"

SRC_URI += "file://0001-postfix-3.5-20190310.patch"
